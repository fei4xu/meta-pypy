PYTHON_BASEVERSION ?= "2.7"
PYTHON_ABI ?= ""
PYTHON_PN = "pypy"
PYTHON_DIR = ""
PYTHON_SITEPACKAGES_DIR = "${prefix}/site-packages"
